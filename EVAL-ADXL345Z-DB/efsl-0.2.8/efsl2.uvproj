# Keil uVision project efsl2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ADuC7024 Analog Devices
  cpu: IRAM(0x10000-0x11FFF) IROM(0x80000-0x8F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: efsl2 (library)
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: __KEIL__
  c include: .\inc;.\conf;.\src\interfaces
  memory RVCT4: ROM 0x80000 size 0xf800
  memory RVCT9: RAM 0x10000 size 0x2000
  group C source
    ./src/: ui.c debug.c dir.c disc.c efs.c extract.c fat.c file.c fs.c ioman.c ls.c mkfs.c partition.c plibc.c regressiontest.c time.c
    ./src/interfaces/: sd.c
