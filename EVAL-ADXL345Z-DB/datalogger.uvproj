# Keil uVision project datalogger.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ADuC7024 Analog Devices
  cpu: IRAM(0x10000-0x11FFF) IROM(0x80000-0x8F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: datalogger +hex
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: __KEIL__
  c include: .\efsl-0.2.8\inc;.\efsl-0.2.8\conf;.\inc
  memory RVCT4: ROM 0x80000 size 0xf800
  memory RVCT9: RAM 0x10000 size 0x2000
  group Source Group 1
    ./: ADuC702x.s debug_printf.c datalogger.c xl345_io_bb.c Retarget.c
    ./efsl-0.2.8/src/interfaces/: aduc702x_spi.c
    ./efsl-0.2.8/: efsl2.lib
